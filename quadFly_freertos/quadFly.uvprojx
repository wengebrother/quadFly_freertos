# Keil uVision project quadFly.uvprojx, settings and files
target quadFly (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quadFly +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,ARM_MATH_CM3
  c include: .\User\AHRS;.\User\Driver\Inc;.\User\Controler\Inc;.\Chip\inc;.\Chip\CMSIS;.\Chip\CMSIS\startup;.\Chip\DSP_Lib\CommonTables;.\Chip\DSP_Lib;.\Chip\USB\Core;.\Chip\USB\Config;.\User\Modules\Inc;.\User\Controler\NCQ_Control;.\User;.\FreeRTos\port\RVDS\ARM_CM3;.\Chip\USB;.\FreeRTos\include;.\User\Sensor;.\User\Message_Queue
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Chip
    ./Chip/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ./User/: Filter.c main.c stm32f10x_it.c FreeRTOSConfig.h TaskTest.c
  group Controler
    ./User/Controler/Src/: Calibration.c IMU.c PID.c ADRC.c NamelessCorun_Ctrl.c NamelessCorun_OpticalFlow.c SINS.c
  group Driver
    ./User/Driver/Src/: Bling.c delay.c FBM320.c FLASH.c GPS.c HMC5883.c IIC.c IST8310.c KEY.c MPU6050.c MS5611.c NRF24L01.c OLED.c PPM.c PWM.c PX4FLOW.c SPI1.c SPI2.c SPL06_001.c SYSTEM.c TIME.c Time_Cnt.c US_100.c USART.c SBUS.c
  group CMSIS
    ./Chip/CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./Chip/CMSIS/startup/arm/: startup_stm32f10x_hd.s
    ./Chip/CMSIS/startup/: core_cm3.c
  group DSP_Lib
    ./Chip/DSP_Lib/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ./Chip/DSP_Lib/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
    ./Chip/DSP_Lib/CommonTables/: arm_common_tables.c
  group Modules
    ./User/Modules/Src/: CalibrationRoutines.c ringbuf.c Earth_Declination.c
    ./User/Modules/Inc/: CalibrationRoutines.h
  group USB/Core
    ./Chip/USB/Core/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group NCQ_Control
    ./User/Controler/NCQ_Control/: control_althold.c control_althold.h control_config.h control_land.c control_land.h control_poshold.c control_poshold.h
  group FreeRTos/port
    ./FreeRTos/port/MemMang/: heap_4.c
    ./FreeRTos/port/RVDS/ARM_CM3/: port.c
  group FreeRTos/src
    ./FreeRTos/Src/: croutine.c event_groups.c list.c tasks.c timers.c queue.c
  group USB/Config
    ./Chip/USB/Config/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
    ./Chip/USB/: N_Queue.c
  group Task
    ./User/Sensor/: sensorTask.c
    ./User/AHRS/: AHRS_Task.c
  group Communication
    ./User/Message_Queue/: Message_Queue.c
